## hw/nvme-msssd/Kconfig
```kconfig
config NVME_MSSSD
    bool
    default y if PCI_DEVICES
    select CXL_MEM_DEVICE
```
